options:
  parameters:
    generate_options: qt_gui
    id: FM_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 90e6
    step: 1e5
    stop: 110e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(48e3)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 100e3
    decim: '8'
    gain: '1'
    samp_rate: sdr_samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Demod Out"'
    type: float
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Bandpass Sample"'
    type: complex
    wintype: window.WIN_KAISER
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '48'
    type: fff
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    gain: '15'
    samp_rate: sdr_samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_bladerf_source_0, '0', low_pass_filter_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
